# Keil uVision project F103xE.uvprojx, settings and files
target F103xE (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F103xE +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\BSP;..\APP;..\BSP\port;..\Package\modbus\ascii;..\Package\modbus\functions;..\Package\modbus\include;..\Package\modbus\rtu;..\Package\modbus;..\BSP\Key;..\BSP\485;..\BSP\Init;..\BSP\adc;..\BSP\add;..\BSP\delay;..\BSP\led;..\BSP\tft;..\BSP\spi
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ../BSP/port/: portevent.c portserial.c porttimer.c
    ../BSP/: bsp_timer2.c bsp_usart.c
    ../BSP/Key/: bsp_key.c
    ../BSP/Init/: bsp_Init.c
    ../BSP/adc/: bsp_adc.c
    ../BSP/add/: add.c
    ../BSP/delay/: delay.c
    ../BSP/led/: bsp_led.c
    ../BSP/tft/: bsp_tft.c
    ../BSP/spi/: bap_spi.c
  group APP
    ../APP/: main.c stm32f10x_it.c
  group DOC
    ../Doc/: readme.md
  group FreeModbus
    ../Package/modbus/ascii/: mbascii.c
    ../Package/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../Package/modbus/rtu/: mbcrc.c mbrtu.c
    ../Package/modbus/: mb.c
